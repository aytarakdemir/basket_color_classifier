Commit message: color detecting and grasping

File: data/table/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.4 0.4 0.05; visual mesh filename=table.obj scale=0.1 0.1 0.58
