Commit message: last update

File: data/cube_blue.urdf (robot description, URDF)
Before this commit: robot cube_green.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 0.02 -> 0.2
